<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt;*.h;*.inc;*.ini</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>AIS_Tranceiver2_Target</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>8000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\List\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Reference Manual</Title>
          <Path>DATASHTS\ST\STM32F10xxx.PDF</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DARMSTM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pSTM32F103RC</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TARMSTM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pSTM32F103RC</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>0</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2CM3.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(105=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=930,138,1164,675,0)(100=-1,-1,-1,-1,0)(110=-1,-1,-1,-1,0)(111=-1,-1,-1,-1,0)(1011=-1,-1,-1,-1,0)(180=-1,-1,-1,-1,0)(120=-1,-1,-1,-1,0)(121=-1,-1,-1,-1,0)(122=-1,-1,-1,-1,0)(123=-1,-1,-1,-1,0)(124=-1,-1,-1,-1,0)(125=-1,-1,-1,-1,0)(126=-1,-1,-1,-1,0)(140=-1,-1,-1,-1,0)(240=-1,-1,-1,-1,0)(190=-1,-1,-1,-1,0)(200=-1,-1,-1,-1,0)(170=-1,-1,-1,-1,0)(130=-1,-1,-1,-1,0)(131=-1,-1,-1,-1,0)(132=-1,-1,-1,-1,0)(133=-1,-1,-1,-1,0)(160=-1,-1,-1,-1,0)(161=-1,-1,-1,-1,0)(162=-1,-1,-1,-1,0)(210=-1,-1,-1,-1,0)(211=-1,-1,-1,-1,0)(220=-1,-1,-1,-1,0)(221=-1,-1,-1,-1,0)(230=-1,-1,-1,-1,0)(231=-1,-1,-1,-1,0)(232=-1,-1,-1,-1,0)(233=-1,-1,-1,-1,0)(150=-1,-1,-1,-1,0)(151=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-UV0168AVR -O206 -S0 -C0 -P00 -N00("ARM CoreSight SW-DP") -D00(1BA01477) -L00(0) -TO19 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_512 -FS08000000 -FL080000</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>usAddr,0x10</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>ulTemp,0x10</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>ucTempBuf</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>ucCheck</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>1</WinNumber>
          <ItemText>usTempBuf</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>1</WinNumber>
          <ItemText>ucDebug</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>1</WinNumber>
          <ItemText>usLen</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>1</WinNumber>
          <ItemText>ucDebug</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>1</WinNumber>
          <ItemText>ucDebug</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>1</WinNumber>
          <ItemText>FileHead.ShipName</ItemText>
        </Ww>
        <Ww>
          <count>10</count>
          <WinNumber>1</WinNumber>
          <ItemText>ShipName</ItemText>
        </Ww>
        <Ww>
          <count>11</count>
          <WinNumber>1</WinNumber>
          <ItemText>AisStaticPara.ShipName</ItemText>
        </Ww>
        <Ww>
          <count>12</count>
          <WinNumber>1</WinNumber>
          <ItemText>AisStaticPara.ShipName</ItemText>
        </Ww>
      </WatchWindow1>
      <WatchWindow2>
        <Ww>
          <count>0</count>
          <WinNumber>2</WinNumber>
          <ItemText>usAddr</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>2</WinNumber>
          <ItemText>usTempBuf</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>2</WinNumber>
          <ItemText>ucTempBuf</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>2</WinNumber>
          <ItemText>ulDefVal,0x10</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>2</WinNumber>
          <ItemText>ucMaxLen</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>2</WinNumber>
          <ItemText>usTempBuf</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>2</WinNumber>
          <ItemText>usTempBuf</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>2</WinNumber>
          <ItemText>ucLen</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>2</WinNumber>
          <ItemText>ucDebug</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>2</WinNumber>
          <ItemText>usTempBuf</ItemText>
        </Ww>
        <Ww>
          <count>10</count>
          <WinNumber>2</WinNumber>
          <ItemText>ucDebug</ItemText>
        </Ww>
        <Ww>
          <count>11</count>
          <WinNumber>2</WinNumber>
          <ItemText>CR_PER_Reset</ItemText>
        </Ww>
      </WatchWindow2>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>0</SubType>
          <ItemText>0x08000372</ItemText>
        </Mm>
      </MemoryWindow1>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>2</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>1</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>start_up</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143732168</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\StartUp\src\cortexm3_macro.s</PathWithFileName>
      <FilenameWithoutPath>cortexm3_macro.s</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143732168</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\StartUp\src\stm32f10x_it.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_it.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143732168</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\StartUp\src\stm32f10x_startup.s</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_startup.s</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143732168</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\StartUp\src\stm32f10x_target.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_target.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>library</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>4</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143748392</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\library\STM32F10xR.LIB</PathWithFileName>
      <FilenameWithoutPath>STM32F10xR.LIB</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143748392</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\library\stm32f10x_sdio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_sdio.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>17</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>17</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\library\stm32f10x_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_flash.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>interface_layer</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\batteryscan.c</PathWithFileName>
      <FilenameWithoutPath>batteryscan.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\ioctrl.c</PathWithFileName>
      <FilenameWithoutPath>ioctrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\keyscan.c</PathWithFileName>
      <FilenameWithoutPath>keyscan.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\parastorage.c</PathWithFileName>
      <FilenameWithoutPath>parastorage.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\RxTxCtrl.c</PathWithFileName>
      <FilenameWithoutPath>RxTxCtrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\systemtick.c</PathWithFileName>
      <FilenameWithoutPath>systemtick.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\DataLinkService.c</PathWithFileName>
      <FilenameWithoutPath>DataLinkService.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\LinkManagementEntity.c</PathWithFileName>
      <FilenameWithoutPath>LinkManagementEntity.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143760752</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\PhysicalLayer.c</PathWithFileName>
      <FilenameWithoutPath>PhysicalLayer.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>ptl</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\ptl\src\AIS_MsgModu.c</PathWithFileName>
      <FilenameWithoutPath>AIS_MsgModu.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\ptl\src\AISDigitalInterface.c</PathWithFileName>
      <FilenameWithoutPath>AISDigitalInterface.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\ptl\src\AISMsgModule.c</PathWithFileName>
      <FilenameWithoutPath>AISMsgModule.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\ptl\src\Slot.c</PathWithFileName>
      <FilenameWithoutPath>Slot.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\ptl\src\TDMA.c</PathWithFileName>
      <FilenameWithoutPath>TDMA.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\interface_layer\Source\DeviceInfo.c</PathWithFileName>
      <FilenameWithoutPath>DeviceInfo.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\ptl\src\AisInfo.c</PathWithFileName>
      <FilenameWithoutPath>AisInfo.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\ptl\src\MsgManager.c</PathWithFileName>
      <FilenameWithoutPath>MsgManager.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>143970664</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\ptl\src\AisPtlMain.c</PathWithFileName>
      <FilenameWithoutPath>AisPtlMain.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>user</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\adjust.c</PathWithFileName>
      <FilenameWithoutPath>adjust.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>27</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\batteryctrl.c</PathWithFileName>
      <FilenameWithoutPath>batteryctrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\common.c</PathWithFileName>
      <FilenameWithoutPath>common.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\gpsctrl.c</PathWithFileName>
      <FilenameWithoutPath>gpsctrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\initial.c</PathWithFileName>
      <FilenameWithoutPath>initial.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>31</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\ledctrl.c</PathWithFileName>
      <FilenameWithoutPath>ledctrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>32</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>33</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\powerdown.c</PathWithFileName>
      <FilenameWithoutPath>powerdown.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>34</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\powerup.c</PathWithFileName>
      <FilenameWithoutPath>powerup.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>35</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\sleepctrl.c</PathWithFileName>
      <FilenameWithoutPath>sleepctrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>36</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\tempersensor.c</PathWithFileName>
      <FilenameWithoutPath>tempersensor.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>37</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\testing.c</PathWithFileName>
      <FilenameWithoutPath>testing.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>38</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\uartmsg.c</PathWithFileName>
      <FilenameWithoutPath>uartmsg.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>39</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\UbloxProtocol.c</PathWithFileName>
      <FilenameWithoutPath>UbloxProtocol.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>40</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\TransceiverCtrl.c</PathWithFileName>
      <FilenameWithoutPath>TransceiverCtrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>41</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\SelfCheck.c</PathWithFileName>
      <FilenameWithoutPath>SelfCheck.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>42</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\RfLinkSelfCheck.c</PathWithFileName>
      <FilenameWithoutPath>RfLinkSelfCheck.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>43</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\TaskManager.c</PathWithFileName>
      <FilenameWithoutPath>TaskManager.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>44</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144004120</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\diskio.c</PathWithFileName>
      <FilenameWithoutPath>diskio.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>1</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\ff.c</PathWithFileName>
      <FilenameWithoutPath>ff.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>46</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>45</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>227</TopLine>
      <CurrentLine>252</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\filectrl.c</PathWithFileName>
      <FilenameWithoutPath>filectrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>47</FileNumber>
      <FileType>1</FileType>
      <tvExp>1</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>237</TopLine>
      <CurrentLine>237</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\flashctrl.c</PathWithFileName>
      <FilenameWithoutPath>flashctrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>48</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>1</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\src\encrypt.c</PathWithFileName>
      <FilenameWithoutPath>encrypt.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>driver</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>49</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\24c02.c</PathWithFileName>
      <FilenameWithoutPath>24c02.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>50</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\Adc.c</PathWithFileName>
      <FilenameWithoutPath>Adc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>51</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\BKPRegister.c</PathWithFileName>
      <FilenameWithoutPath>BKPRegister.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>52</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\DAC.c</PathWithFileName>
      <FilenameWithoutPath>DAC.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>53</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\gps.c</PathWithFileName>
      <FilenameWithoutPath>gps.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>54</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\LED.c</PathWithFileName>
      <FilenameWithoutPath>LED.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>55</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\power.c</PathWithFileName>
      <FilenameWithoutPath>power.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>56</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\rtc.c</PathWithFileName>
      <FilenameWithoutPath>rtc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>57</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\RxTx.c</PathWithFileName>
      <FilenameWithoutPath>RxTx.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>58</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\SPI.c</PathWithFileName>
      <FilenameWithoutPath>SPI.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>59</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\Tim.c</PathWithFileName>
      <FilenameWithoutPath>Tim.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>60</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\usart.c</PathWithFileName>
      <FilenameWithoutPath>usart.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>61</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\wdg.c</PathWithFileName>
      <FilenameWithoutPath>wdg.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>62</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\gpiospi.c</PathWithFileName>
      <FilenameWithoutPath>gpiospi.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>63</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\Si446x.c</PathWithFileName>
      <FilenameWithoutPath>Si446x.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>64</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144086864</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\driver\src\sdcard.c</PathWithFileName>
      <FilenameWithoutPath>sdcard.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>debug</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>65</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144144744</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\debug\src\debug.c</PathWithFileName>
      <FilenameWithoutPath>debug.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>document</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
  </Group>

  <Group>
    <GroupName>log</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>66</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144151696</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Tranceiver2_Bugs.txt</PathWithFileName>
      <FilenameWithoutPath>Tranceiver2_Bugs.txt</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>67</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144151696</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Tranceiver2_Notes.txt</PathWithFileName>
      <FilenameWithoutPath>Tranceiver2_Notes.txt</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>68</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144151696</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Tranceiver2_Remains.txt</PathWithFileName>
      <FilenameWithoutPath>Tranceiver2_Remains.txt</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>69</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>144151696</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23626604</TopLine>
      <CurrentLine>3018520</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\version.ini</PathWithFileName>
      <FilenameWithoutPath>version.ini</FilenameWithoutPath>
    </File>
  </Group>

</ProjectOpt>
