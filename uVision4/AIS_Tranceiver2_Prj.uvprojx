# Keil uVision project AIS_Tranceiver2_Prj.uvprojx, settings and files
target AIS_Tranceiver2_Target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AIS_Tranceiver2_Prj +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\interface_layer\Include;..\StartUp\inc;..\user\inc;..\driver\inc;..\debug\inc;..\ptl\inc;..\library;..\StdPeriph_Driver\inc;..\StdPeriph_Driver\src;..\migrateF4to5;..\PTT_lnw\inc;..\PTT_lnw\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group start_up
    ../StartUp/src/: cortexm3_macro.s stm32f10x_target.c stm32f10x_it.c stm32f10x_startup.s
  group interface_layer
    ../interface_layer/Source/: batteryscan.c ioctrl.c keyscan.c parastorage.c RxTxCtrl.c systemtick.c DataLinkService.c LinkManagementEntity.c PhysicalLayer.c
  group ptl
    ../ptl/src/: AIS_MsgModu.c AISDigitalInterface.c AISMsgModule.c Slot.c TDMA.c AisInfo.c MsgManager.c AisPtlMain.c
    ../interface_layer/Source/: DeviceInfo.c
  group user
    ../user/src/: adjust.c batteryctrl.c common.c gpsctrl.c initial.c ledctrl.c main.c powerdown.c powerup.c sleepctrl.c tempersensor.c testing.c uartmsg.c UbloxProtocol.c TransceiverCtrl.c SelfCheck.c RfLinkSelfCheck.c TaskManager.c diskio.c ff.c filectrl.c flashctrl.c encrypt.c
  group driver
    ../driver/src/: 24c02.c Adc.c BKPRegister.c DAC.c gps.c LED.c power.c rtc.c RxTx.c SPI.c Tim.c usart.c wdg.c gpiospi.c Si446x.c sdcard.c
  group debug
    ../debug/src/: debug.c
  group log
    ../: Tranceiver2_Bugs.txt Tranceiver2_Notes.txt Tranceiver2_Remains.txt version.ini
  group StdLib
    ../StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group migrate
    ../migrateF4to5/: migrate.c
  group PTT_lnw
    ../PTT_lnw/src/: PTT_lnw.c
    ../PTT_lnw/inc/: PTT_lnw.h
